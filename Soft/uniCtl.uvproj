# Keil uVision project uniCtl.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ..\hex\DetectorM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\code\TimeCtl;.\code\Board;.\code\BuffOut;.\code;.\code\BuffIn;.\code\GPIn;.\code\GPOut;.\code\WordIn;.\code\WordOut;.\code\Control;.\code\UserVsEngine;.\code\Abstract
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./code/: LPC2148Service.cpp Startup2148.s Detector.cpp
  group Time
    ./code/TimeCtl/: Metronome_lpc2148.cpp
  group Board
    ./code/Board/: DetectorBoard.cpp
  group bufferIO
    ./code/BuffOut/: BuffOut.cpp LPC2148_UART.cpp
    ./code/BuffIn/: BuffIn.cpp
  group GP_Out
    ./code/GPOut/: LPC2148_PinOut.cpp
  group WordIn
    ./code/WordIn/: Uc_ADC.cpp
